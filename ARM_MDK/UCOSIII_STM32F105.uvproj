# Keil uVision project UCOSIII_STM32F105.uvproj, settings and files
target UCOSIII_STM32F105 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: UCOSIII_STM32F105 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\BSP;..\STM32_StdPeriph_Library\CMSIS\CoreSupport;..\STM32_StdPeriph_Library\CMSIS\DeviceSupport\ST\STM32F10x;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\STM32_StdPeriph_Library\STM32F10X_CONF_H;..\STM32_StdPeriph_Library\STM32F10x_StdPeriph_Driver\inc;..\UCOSIII
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s
  group CMSIS
    ../STM32_StdPeriph_Library/CMSIS/CoreSupport/: core_cm3.c
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group uC/CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c lib_math.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OSIII_Port
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group uC/OSIII_Source
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_prio.c
  group BSP
    ../BSP/: bsp.c led.c stm32f10x_it.c
  group Main
    ../Main/: main.c
  group STM32_StdPeriph_Library
    ../STM32_StdPeriph_Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group Readme
    ../Readme/: Readme.txt
